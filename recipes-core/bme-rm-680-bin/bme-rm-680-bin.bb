# Copyright (C) 2016 Aleksi Suomalainen <suomalainen.aleksi@gmail.com>
# Released under the MIT license (see COPYING.MIT for the terms)

DESCRIPTION = "BME binaries from Nokia"
LICENSE = "file://license.txt"

SRC_URI = "file://bme-rm-680-bin-0.9.95-4.1-armv7hl.tar.bz2"
